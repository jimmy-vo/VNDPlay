# Keil uVision project BalaPi_stm32f4.uvproj, settings and files
target balaPi (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SENSE +hex
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX, ARM_MATH_CM4
  c include: ..\inc;..\_Code_;..\_Code_\DEV;..\_Code_\LCD\TFT_Service;..\_Code_\Timing;..\_Code_\Storage;..\_Code_\User;..\_Code_\Matrix;..\_Code_\DEV\FATFS;..\_Code_\Sensor\Filter;..\_Code_\User\APP_Sudoku;..\_Code_\User\APP_Bluetooth;..\_Code_\User\APP_Others;..\_Code_\TFT;..\_Code_\TFT\TFT_Service;..\_Code_\Gameboy;..\_Code_\Gameboy\nes;..\_Code_\Gameboy\rom;..\_Code_\User\APP_RobotArmControl;..\_Code_\User\APP_Shellmo;..\_Code_\User\APP_IMU;..\_Code_\User\APP_Snake;..\_Code_\User\APP_Main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../_Code_/User/: main.c Voltage_FB.c RGB.c Input.c
  group APP_Main
    ../_Code_/User/APP_Main/: APP_Main.c
  group APP_Sudoku
    ../_Code_/User/APP_Sudoku/: Sudoku.c Sudoku_Event.c Sudoku_Layout.c
  group APP_Snake
    ../_Code_/User/APP_Snake/: APP_Snake.c
  group APP_Bluetooth
    ../_Code_/User/APP_Bluetooth/: Bluetooth.c Bluetooth_Event.c Bluetooth_Layout.c Serial_Link_string.c Bluetooth_ATCMD.c
  group APP_RobotArm
    ../_Code_/User/APP_RobotArmControl/: APP_RobotArm.c
  group APP_Shellmo
    ../_Code_/User/APP_Shellmo/: APP_Shellmo.c
  group APP_Others
    ../_Code_/User/APP_Others/: APP_Test.c
  group Sensor
    ../_Code_/User/APP_IMU/: APP_IMU.c MPU6050.c SENSOR_DATA.c
  group Timing
    ../_Code_/Timing/: Timing_Manage.c
  group TFT_Service
    ../_Code_/TFT/TFT_Service/: AsciiLib.c TFTService_Dialog.c TFTService_Draw.c TFTService_Text.c TFTService_Keyboard.c TFTService_TrackBar.c TFTService_Button.c
  group TFT_Lowlevel
    ../_Code_/TFT/: TFT_TouchPanel.c TFT_SSD1289.c TFT_XPT2046.c
  group DEV
    ../_Code_/DEV/: DEV_ADC.c Dev_DIGITAL.c Dev_I2C.c Dev_TIMER.c Dev_USART.c
  group System
    ./: startup_stm32f4xx.s
    ../_Code_/: system_stm32f4xx.c
  group Peripheral Library
    ../src/: stm32f4xx_syscfg.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_fsmc.c
